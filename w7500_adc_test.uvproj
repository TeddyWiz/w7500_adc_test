# Keil uVision project w7500_adc_test.uvproj, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: w7500_adc_test
  AfterMake: $K\ARM\ARMCC\BIN\fromelf.exe #L --vhx --8x1 --output main.hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=4 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: CORTEX_M0 USE_STDPERIPH_DRIVER
  c include: .\W7500\W7500x_Library_Examples\Libraries\CMSIS\Device\WIZnet\W7500\Include;.\W7500\W7500x_Library_Examples\Libraries\W7500x_stdPeriph_Driver\inc;.\W7500\W7500x_Library_Examples\Libraries\CMSIS\Include;..\01_w7500_adc_test
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group MDK_ARM
    ./W7500/W7500x_Library_Examples/Libraries/CMSIS/Device/WIZnet/W7500/Source/ARM/: startup_W7500x.s
  group CMSIS
    ./W7500/W7500x_Library_Examples/Libraries/CMSIS/Device/WIZnet/W7500/Source/: system_W7500x.c
  group W7500_Periphs
    ./W7500/W7500x_Library_Examples/Libraries/W7500x_stdPeriph_Driver/src/: W7500x_adc.c W7500x_exti.c W7500x_gpio.c W7500x_uart.c
  group User
    ./: main.c W7500x_it.c W7500x_it.h
