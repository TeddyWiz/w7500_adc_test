# Keil uVision project W7500x_WZTOE_httpServer.uvproj, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: W7500x_WZTOE_httpServer
  AfterMake: $K\ARM\ARMCC\BIN\fromelf.exe #L --vhx --8x1 --output main.hex;fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=4 v6Lang=1 v6LangP=1
  c define: CORTEX_M0 USE_STDPERIPH_DRIVER
  c include: ..\..\..\..\..\Libraries\CMSIS\Device\WIZnet\W7500\Source\ARM;..\..\..\..\..\Libraries\CMSIS\Device\WIZnet\W7500\Include;..\..\..\..\..\Libraries\W7500x_stdPeriph_Driver\inc;..\..\..\..\..\Libraries\CMSIS\Include;..\;..\..\..\..\..\ioLibrary\MDIO;..\..\..\..\..\ioLibrary\Ethernet;..\..\..\..\..\ioLibrary\Application\loopback;..\..\..\..\..\ioLibrary\Internet\httpServer
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group MDK-ARM
    ../../../../../Libraries/CMSIS/Device/WIZnet/W7500/Source/ARM/: startup_W7500x.s
  group W7500x_Periph
    ../../../../../Libraries/W7500x_stdPeriph_Driver/src/: W7500x_crg.c W7500x_gpio.c W7500x_uart.c W7500x_wztoe.c
  group CMSIS
    ../../../../../Libraries/CMSIS/Device/WIZnet/W7500/Source/: system_W7500x.c
  group User
    ../: main.c retarget.c W7500x_it.c
  group ioLibrary
    ../../../../../ioLibrary/Ethernet/: socket.c wizchip_conf.c
    ../../../../../ioLibrary/Internet/httpServer/: httpParser.c httpServer.c httpUtil.c
    ../../../../../ioLibrary/MDIO/: W7500x_miim.c
  group Applications
    ../../../../../ioLibrary/Application/loopback/: loopback.c
